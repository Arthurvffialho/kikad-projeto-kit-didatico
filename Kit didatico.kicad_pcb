# Repository Arthurvffialho/kikad-projeto-kit-didatico

## KiCad design Kit didatico.kicad_pcb

Board: 2 copper layers, 0.0 x 18.0 mm, 129 parts (0 on the bottom side), 115 nets.

Parts:
BZ1: Buzzer 5V; Buzzer_12x9.5RM7.6
D1, D2, D3, D4, D5, D6, D7, D8: SFH4356P; LED_D3.0mm_IRBlack
D9: LED_RGB; LED_RGB_5050-6
D10: LED; LED_D3.0mm_IRBlack
IC1: ESP32-S3-WROOM-1-N8R2; ESP32S3WROOM1N8R2
J1, J8: Conn_01x03_Female; PinSocket_1x03_P2.54mm_Vertical
J2, J5: Conn_01x04_Female; PinSocket_1x04_P2.54mm_Vertical
J3, J4: Conn_01x05_Female; PinSocket_1x05_P2.54mm_Vertical
J6, J7: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical
J9: Jack-DC; BarrelJack_SwitchcraftConxall_RAPC10U_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R61, R62, R63, R64, R65, R66, R67, R68, R83: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R20, R21, R22, R23, R24, R25, R26, R27, R54, R55, R56, R57, R58, R59, R60, R86: 180; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R69, R76, R77, R78, R79, R81, R82, R84, R85: 5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R70, R71, R72, R75: 1K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R73, R74: 5K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R80: LDR03; R_LDR_10x8.5mm_P7.6mm_Vertical
RV1: R_Potentiometer_Trim; Potentiometer_ACP_CA9-V10_Vertical
SW1, SW11, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20: SW_Push; SW_CW_GPTS203211B
SW2, SW4: SW_DIP_x04; SW_DIP_SPSTx04_Slide_6.7x11.72mm_W6.73mm_P2.54mm_LowProfile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
SW3: SW_DIP_x03; SW_DIP_SPSTx03_Slide_6.7x9.18mm_W6.73mm_P2.54mm_LowProfile_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
SW5, SW6: SW_DIP_x05; SW_DIP_SPSTx05_Slide_6.7x14.26mm_W6.73mm_P2.54mm_LowProfile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
SW7, SW8, SW9, SW10: SW_DIP_x08; SW_DIP_SPSTx08_Slide_6.7x21.88mm_W6.73mm_P2.54mm_LowProfile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
SW12: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
U1: D168K; D1X8K

Connections:
3V3: IC1.2 (3V3), IC1.38 (IO2), J9.1, R69.1, R75.2, R76.1, R77.2, R78.2, R79.2, R81.1, R82.2, R84.2, R85.2, RV1.3
EN: IC1.3 (EN), R76.2, SW13.1
GND_1: BZ1.2 (+), D9.1 (RK), D9.2 (GK), D9.3 (BK), D10.1 (K), IC1.1 (GND_1), IC1.40 (GND_2), IC1.41 (GND_3), IC1.42 (GND_4), IC1.43 (GND_5), IC1.44 (GND_6), IC1.45 (GND_7), IC1.46 (GND_8), IC1.47 (GND_9), IC1.48 (GND_10), IC1.49 (GND_11), J8.1, J9.2, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R28.1, R29.1, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.1, R39.1, R40.1, R41.1, R42.1, R43.1, R44.1, R45.1, R46.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, R67.2, R68.2, R80.2, RV1.1, SW1.2, SW11.2, SW12.C, SW12.S2, SW13.2, SW14.2, SW15.2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
IO0: IC1.27 (IO0), R83.1
IO1: IC1.39 (IO1), R81.2, SW17.1
IO3: IC1.15 (IO3), SW6.8, SW7.11, SW9.11
IO4: IC1.4 (IO4), R85.1, SW18.1
IO5: IC1.5 (IO5), R84.1, SW19.1
IO6: IC1.6 (IO6), R82.1, SW20.1
IO7: IC1.7 (IO7), R79.1, SW14.1
IO8: IC1.12 (IO8), SW2.7, SW7.14, SW9.14
IO9: IC1.17 (IO9), SW6.6, SW7.9, SW9.9
IO10: IC1.18 (IO10), SW3.3, SW5.5, SW8.16, SW10.16
IO11: IC1.19 (IO11), SW3.2, SW5.4, SW8.15, SW10.15
IO12: IC1.20 (IO12), SW3.1, SW5.3, SW8.14, SW10.14
IO13: IC1.21 (IO13), SW4.4, SW5.2, SW8.13, SW10.13
IO14: IC1.22 (IO14), SW4.3, SW5.1, SW8.12, SW10.12
IO15: IC1.8 (IO15), R78.1, SW15.1
IO16: IC1.9 (IO16), R77.1, SW16.1
IO17: IC1.10 (IO17), SW7.16, SW9.16
IO18: IC1.11 (IO18), SW2.8, SW7.15, SW9.15
IO19: IC1.13 (IO19), SW2.6, SW6.10, SW7.13, SW9.13
IO20: IC1.14 (IO20), SW2.5, SW6.9, SW7.12, SW9.12
IO21: IC1.23 (IO21), SW4.2, SW8.11, SW10.11
IO35: IC1.28 (IO35), R70.2
IO36: IC1.29 (IO36), R71.2
IO37: IC1.30 (IO37), R72.2
IO38: IC1.31 (IO38), R80.1
IO39: IC1.32 (IO39), RV1.2
IO40: IC1.33 (IO40), R73.2
IO41: IC1.34 (IO41), R74.2
IO42: IC1.35 (IO42), R75.1, SW12.S1
IO45: BZ1.1 (-), IC1.26 (IO45)
IO46: IC1.16 (IO46), SW6.7, SW7.10, SW9.10
IO47: IC1.24 (IO47), SW4.1, SW8.10, SW10.10
IO48: IC1.25 (IO48), SW8.9, SW10.9
unnamed: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), SW1.1
unnamed: D1.2 (A), R20.1
unnamed: D2.2 (A), R21.1
unnamed: D3.2 (A), R22.1
unnamed: D4.2 (A), R23.1
unnamed: D5.2 (A), R24.1
unnamed: D6.2 (A), R25.1
unnamed: D7.2 (A), R26.1
unnamed: D8.2 (A), R27.1
unnamed: D9.4 (BA), R72.1
unnamed: D9.5 (GA), R71.1
unnamed: D9.6 (RA), R70.1
unnamed: D10.2 (A), R83.2
unnamed: J1.1, R17.2, SW3.4
unnamed: J1.2, R12.2, SW3.5
unnamed: J1.3, R7.2, SW3.6
unnamed: J2.1, R1.2, SW2.1
unnamed: J2.2, R4.2, SW2.2
unnamed: J2.3, R9.2, SW2.3
unnamed: J2.4, R14.2, SW2.4
unnamed: J3.1, R2.2, SW5.10
unnamed: J3.2, R6.2, SW5.9
unnamed: J3.3, R11.2, SW5.8
unnamed: J3.4, R16.2, SW5.7
unnamed: J3.5, R28.2, SW5.6
unnamed: J4.1, R5.2, SW6.1
unnamed: J4.2, R10.2, SW6.2
unnamed: J4.3, R15.2, SW6.3
unnamed: J4.4, R19.2, SW6.4
unnamed: J4.5, R29.2, SW6.5
unnamed: J5.1, R3.2, SW4.8
unnamed: J5.2, R8.2, SW4.7
unnamed: J5.3, R13.2, SW4.6
unnamed: J5.4, R18.2, SW4.5
unnamed: J6.1, R38.2, SW9.1
unnamed: J6.2, R39.2, SW9.2
unnamed: J6.3, R40.2, SW9.3
unnamed: J6.4, R41.2, SW9.4
unnamed: J6.5, R42.2, SW9.5
unnamed: J6.6, R43.2, SW9.6
unnamed: J6.7, R44.2, SW9.7
unnamed: J6.8, R45.2, SW9.8
unnamed: J7.1, R68.1, SW10.1
unnamed: J7.2, R67.1, SW10.2
unnamed: J7.3, R66.1, SW10.3
unnamed: J7.4, R65.1, SW10.4
unnamed: J7.5, R64.1, SW10.5
unnamed: J7.6, R63.1, SW10.6
unnamed: J7.7, R62.1, SW10.7
unnamed: J7.8, R61.1, SW10.8
unnamed: R20.2, R37.1, SW7.1
unnamed: R21.2, R36.1, SW7.2
unnamed: R22.2, R35.1, SW7.3
unnamed: R23.2, R34.1, SW7.4
unnamed: R24.2, R33.1, SW7.5
unnamed: R25.2, R32.1, SW7.6
unnamed: R26.2, R31.1, SW7.7
unnamed: R27.2, R30.1, SW7.8
unnamed: R46.1, R86.1, SW8.1
unnamed: R47.1, R60.1, SW8.2
unnamed: R48.1, R59.1, SW8.3
unnamed: R49.1, R58.1, SW8.4
unnamed: R50.1, R57.1, SW8.5
unnamed: R51.1, R56.1, SW8.6
unnamed: R52.1, R55.1, SW8.7
unnamed: R53.1, R54.1, SW8.8
unnamed: R54.2, U1.7 (A)
unnamed: R55.2, U1.6 (B)
unnamed: R56.2, U1.4 (C)
unnamed: R57.2, U1.2 (D)
unnamed: R58.2, U1.1 (E)
unnamed: R59.2, U1.9 (F)
unnamed: R60.2, U1.10 (G)
unnamed: R69.2, SW11.1, U1.3 (CC), U1.8 (CC)
unnamed: R73.1, SW12.B
unnamed: R74.1, SW12.A
unnamed: R86.2, U1.5 (DP)
RXD0: IC1.36 (RXD0), J8.3
TXD0: IC1.37 (TXD0), J8.2
